# Keil uVision project Encoder_test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Encoder_test
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: Encoder_test.c
    ../: startup_TM4C123.s
  group Source2
    ../tiva_code_1/: SysTick.c UART.c SysTick.h TM4C123GH6PM.h UART.h
    ./: PLL.c PLL.h
