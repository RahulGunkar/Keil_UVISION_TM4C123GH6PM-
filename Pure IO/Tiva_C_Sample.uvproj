# Keil uVision project Tiva_C_Sample.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Tiva_C_Sample
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    D:/Keil/ARM/Startup/TI/TM4C123/: startup_TM4C123.s
    ./: PLL.h PLL.c
    ./pwm_tiva_C/: SysTick.c UART.c SysTick.h UART.h
  group Source
    ./pwm_tiva_C/: pwm_sample.c
