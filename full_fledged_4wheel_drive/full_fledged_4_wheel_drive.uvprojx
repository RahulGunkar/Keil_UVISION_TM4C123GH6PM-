# Keil uVision project full_fledged_4_wheel_drive.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: full_fledged_4_wheel_drive
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source
    ./: startup_TM4C123.s main.c
  group cradle
    ./: PLL.c SysTick.c UART.c PLL.h SysTick.h TM4C123GH6PM.h UART.h fifo.c Queue_Lib.c fifo.h Queue_Lib.h
